# Keil uVision project timer_a_upmode_gpio_toggle.uvprojx, settings and files
target Msp432Car (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: timer_a_upmode_gpio_toggle
  AfterMake: fromelf --bin --output .\Build\timer_a_upmode_gpio_toggle.bin .\Build\timer_a_upmode_gpio_toggle.axf
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __MSP432P401R__ TARGET_IS_MSP432P4XX keil
  c include: ..\ti\driverlib\MSP432P4xx;..\lib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ../: Msp432CarMain.c
  group Library
    ../ti/driverlib/MSP432P4xx/keil/: msp432p4xx_driverlib.lib
  group lib
    ../lib/: delay.c delay.h key.c key.h sysinit.c sysinit.h timA.c timA.h PID.c PID.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.2
